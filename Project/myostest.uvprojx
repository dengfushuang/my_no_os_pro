# Keil uVision project myostest.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1778 NXP
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: myostest +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Libraries\Core;..\User;..\Libraries\Drivers\include;..\Hardware\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group User
    ../User/: main.c
  group Startup
    ../Startup/: startup_LPC17xx.s
    ../Libraries/Core/: core_cm3.c system_LPC177x_8x.c
  group Libraries
    ../Libraries/Drivers/source/: lpc177x_8x_clkpwr.c lpc177x_8x_gpio.c lpc177x_8x_systick.c lpc177x_8x_uart.c
  group Hardware
    ../Hardware/src/: uart0.c
